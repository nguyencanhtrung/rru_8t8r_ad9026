| / 7'7
| \ \   Xilinx Inc.
| / /
| \_\/.\   IBIS Models for Zynq UltraScale Plus
[IBIS ver]   5.1
[File name]   synth.ibs
[File Rev]   2.11
[Date]   Mon May 27 14:33:43 2024
[Source]   Derived from spice models, rev1.0, using
   hspice 2014.09-SP1-2
[Notes]   Xilinx IBIS file for Zynq UltraScale Plus I/O standards.
   All models are preliminary.
   The version of IBISCHK used is ibischk5 V6.0.1.
[Disclaimer] The data in this file is derived from SPICE simulations using
                 modeling information extracted from the target process.
                 A great deal of care has been taken to provide information
                 that is accurate. This model has been verified by actual silicon
                 measurement.
[Copyright]   Copyright 2016, Xilinx Inc., All rights reserved
|   Component Zynq UltraScale Plus
[Component]   zynquplus
[Manufacturer]   Xilinx Inc.
[Package]
|FFVB1156
|variable   typ   min   max
R_pkg   608m   128m   1190m
L_pkg   4.32nH   1.27nH   7.91nH
C_pkg   2.48pF   1.28pF   3.95pF
[Pin]   signal_name   model_name  R_pin  L_pin  C_pin
A1   GND   GND 0m 0nH 0pF
A2   GND   GND 0m 0nH 0pF
A3   MGTHRXN3_230   NC
A4   MGTHRXP3_230   NC
A5   MGTAVTTRCAL_R   NC
A6   MGTRREF_R   NC
A7   MGTHTXN3_230   NC
A8   MGTHTXP3_230   NC
A9   GND   GND 0m 0nH 0pF
A10   MGTAVCC_R   POWER 50m 0.40nH 235nF
A11   GND   GND 0m 0nH 0pF
A12   IO_L9N_AD11N_49   NC
A13   IO_L9P_AD11P_49   NC
A14   GND   GND 0m 0nH 0pF
A15   IO_L4N_AD12N_49   NC
A16   IO_L3N_AD13N_49   NC
A17   IO_L12P_AD8P_48   NC
A18   IO_L12N_AD8N_48   NC
A19   GND   GND 0m 0nH 0pF
A20   IO_L12N_AD0N_47   NC
A21   IO_L11P_AD1P_47   NC
A22   IO_L11N_AD1N_47   NC
A23   USB0_ULPI_TX_DATA[1]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
A24   GND   GND 0m 0nH 0pF
A25   GEM3_RGMII_TX_CLK   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
A26   GEM3_RGMII_TXD[0]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
A27   GEM3_RGMII_TXD[1]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
A28   GND   GND 0m 0nH 0pF
A29   MGTRREF_L   NC
A30   MGTAVTTRCAL_L   NC
A31   tx2_data_p[3]   NC
A32   tx2_data_n[3]   NC
A33   GND   GND 0m 0nH 0pF
A34   GND   GND 0m 0nH 0pF
B1   MGTHRXN2_230   NC
B2   MGTHRXP2_230   NC
B3   MGTAVTT_R   POWER 50m 0.40nH 235nF
B4   GND   GND 0m 0nH 0pF
B5   MGTHTXN2_230   NC
B6   MGTHTXP2_230   NC
B7   GND   GND 0m 0nH 0pF
B8   MGTAVCC_R   POWER 50m 0.40nH 235nF
B9   MGTREFCLK1N_230   NC
B10   MGTREFCLK1P_230   NC
B11   GND   GND 0m 0nH 0pF
B12   IO_L10N_AD10N_49   NC
B13   IO_L8N_HDGC_49   NC
B14   IO_L7N_HDGC_49   NC
B15   IO_L4P_AD12P_49   NC
B16   IO_L3P_AD13P_49   NC
B17   GND   GND 0m 0nH 0pF
B18   IO_L10P_AD10P_48   NC
B19   IO_L10N_AD10N_48   NC
B20   IO_L12P_AD0P_47   NC
B21   IO_L10N_AD2N_47   NC
B22   GND   GND 0m 0nH 0pF
B23   USB0_ULPI_NXT   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
B24   USB0_ULPI_TX_DATA[3]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
B25   GEM3_RGMII_TXD[2]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
B26   GEM3_RGMII_TXD[3]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
B27   GEM3_RGMII_TX_CTL   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
B28   GND   GND 0m 0nH 0pF
B29   tx2_data_p[2]   NC
B30   tx2_data_n[2]   NC
B31   MGTAVTT_L   POWER 50m 0.40nH 235nF
B32   GND   GND 0m 0nH 0pF
B33   rx2_data_p[3]   NC
B34   rx2_data_n[3]   NC
C1   GND   GND 0m 0nH 0pF
C2   GND   GND 0m 0nH 0pF
C3   MGTHRXN1_230   NC
C4   MGTHRXP1_230   NC
C5   GND   GND 0m 0nH 0pF
C6   MGTAVCC_R   POWER 50m 0.40nH 235nF
C7   MGTREFCLK0N_230   NC
C8   MGTREFCLK0P_230   NC
C9   GND   GND 0m 0nH 0pF
C10   GND   GND 0m 0nH 0pF
C11   GND   GND 0m 0nH 0pF
C12   IO_L10P_AD10P_49   NC
C13   IO_L8P_HDGC_49   NC
C14   IO_L7P_HDGC_49   NC
C15   GND   GND 0m 0nH 0pF
C16   IO_L2N_AD14N_49   NC
C17   IO_L9N_AD11N_48   NC
C18   IO_L11P_AD9P_48   NC
C19   IO_L11N_AD9N_48   NC
C20   GND   GND 0m 0nH 0pF
C21   IO_L10P_AD2P_47   NC
C22   IO_L9N_AD3N_47   NC
C23   USB0_ULPI_TX_DATA[0]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
C24   USB0_ULPI_TX_DATA[5]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
C25   GND   GND 0m 0nH 0pF
C26   GEM3_RGMII_RX_CLK   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
C27   GEM3_RGMII_RXD[0]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
C28   GND   GND 0m 0nH 0pF
C29   MGTAVTT_L   POWER 50m 0.40nH 235nF
C30   GND   GND 0m 0nH 0pF
C31   rx2_data_p[2]   NC
C32   rx2_data_n[2]   NC
C33   GND   GND 0m 0nH 0pF
C34   GND   GND 0m 0nH 0pF
D1   MGTHRXN0_230   NC
D2   MGTHRXP0_230   NC
D3   GND   GND 0m 0nH 0pF
D4   MGTAVTT_R   POWER 50m 0.40nH 235nF
D5   MGTHTXN1_230   NC
D6   MGTHTXP1_230   NC
D7   MGTAVCC_R   POWER 50m 0.40nH 235nF
D8   GND   GND 0m 0nH 0pF
D9   GND   GND 0m 0nH 0pF
D10   IO_L4N_AD12N_50   NC
D11   IO_L4P_AD12P_50   NC
D12   IO_L11N_AD9N_49   NC
D13   GND   GND 0m 0nH 0pF
D14   IO_L6N_HDGC_49   NC
D15   IO_L5N_HDGC_49   NC
D16   IO_L2P_AD14P_49   NC
D17   IO_L9P_AD11P_48   NC
D18   GND   GND 0m 0nH 0pF
D19   IO_L7N_HDGC_48   NC
D20   IO_L8N_HDGC_AD4N_47   NC
D21   IO_L9P_AD3P_47   NC
D22   IO_L7N_HDGC_AD5N_47   NC
D23   VCCO_PSIO2_502   POWER 50m 0.40nH 235nF
D24   USB0_ULPI_TX_DATA[7]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
D25   GEM3_RGMII_RX_CTL   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
D26   GND   GND 0m 0nH 0pF
D27   GND   GND 0m 0nH 0pF
D28   GND   GND 0m 0nH 0pF
D29   tx2_data_p[1]   NC
D30   tx2_data_n[1]   NC
D31   GND   GND 0m 0nH 0pF
D32   MGTAVTT_L   POWER 50m 0.40nH 235nF
D33   rx2_data_p[1]   NC
D34   rx2_data_n[1]   NC
E1   GND   GND 0m 0nH 0pF
E2   GND   GND 0m 0nH 0pF
E3   MGTHTXN0_230   NC
E4   MGTHTXP0_230   NC
E5   MGTAVCC_R   POWER 50m 0.40nH 235nF
E6   GND   GND 0m 0nH 0pF
E7   MGTREFCLK1N_229   NC
E8   MGTREFCLK1P_229   NC
E9   GND   GND 0m 0nH 0pF
E10   IO_L3N_AD13N_50   NC
E11   GND   GND 0m 0nH 0pF
E12   IO_L11P_AD9P_49   NC
E13   IO_L12N_AD8N_49   NC
E14   IO_L6P_HDGC_49   NC
E15   IO_L5P_HDGC_49   NC
E16   VCCO_49   POWER 50m 0.40nH 235nF
E17   IO_L8P_HDGC_48   NC
E18   IO_L8N_HDGC_48   NC
E19   IO_L7P_HDGC_48   NC
E20   IO_L8P_HDGC_AD4P_47   NC
E21   VCCO_47   POWER 50m 0.40nH 235nF
E22   IO_L7P_HDGC_AD5P_47   NC
E23   USB0_ULPI_DIR   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
E24   USB0_ULPI_TX_DATA[4]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
E25   GEM3_RGMII_RXD[1]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
E26   GND   GND 0m 0nH 0pF
E27   MGTREFCLK1P_130   NC
E28   MGTREFCLK1N_130   NC
E29   GND   GND 0m 0nH 0pF
E30   MGTAVTT_L   POWER 50m 0.40nH 235nF
E31   rx2_data_p[0]   NC
E32   rx2_data_n[0]   NC
E33   GND   GND 0m 0nH 0pF
E34   GND   GND 0m 0nH 0pF
F1   MGTHRXN3_229   NC
F2   MGTHRXP3_229   NC
F3   MGTAVTT_R   POWER 50m 0.40nH 235nF
F4   GND   GND 0m 0nH 0pF
F5   MGTHTXN3_229   NC
F6   MGTHTXP3_229   NC
F7   GND   GND 0m 0nH 0pF
F8   MGTVCCAUX_R   POWER 50m 0.40nH 235nF
F9   GND   GND 0m 0nH 0pF
F10   IO_L3P_AD13P_50   NC
F11   IO_L6N_HDGC_50   NC
F12   IO_L6P_HDGC_50   NC
F13   IO_L12P_AD8P_49   NC
F14   VCCO_49   POWER 50m 0.40nH 235nF
F15   IO_L1N_AD15N_49   NC
F16   IO_L1P_AD15P_49   NC
F17   IO_L6P_HDGC_48   NC
F18   IO_L6N_HDGC_48   NC
F19   GND   GND 0m 0nH 0pF
F20   IO_L6N_HDGC_AD6N_47   NC
F21   IO_L5N_HDGC_AD7N_47   NC
F22   USB0_ULPI_CLK_IN   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
F23   USB0_ULPI_TX_DATA[2]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
F24   VCCO_PSIO2_502   POWER 50m 0.40nH 235nF
F25   MDIO3_GEM3_MDIO_OUT   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
F26   GND   GND 0m 0nH 0pF
F27   GND   GND 0m 0nH 0pF
F28   MGTAVCC_L   POWER 50m 0.40nH 235nF
F29   tx2_data_p[0]   NC
F30   tx2_data_n[0]   NC
F31   MGTAVTT_L   POWER 50m 0.40nH 235nF
F32   GND   GND 0m 0nH 0pF
F33   rx1_data_p[3]   NC
F34   rx1_data_n[3]   NC
G1   GND   GND 0m 0nH 0pF
G2   GND   GND 0m 0nH 0pF
G3   MGTHTXN2_229   NC
G4   MGTHTXP2_229   NC
G5   GND   GND 0m 0nH 0pF
G6   MGTAVCC_R   POWER 50m 0.40nH 235nF
G7   MGTREFCLK0N_229   NC
G8   MGTREFCLK0P_229   NC
G9   GND   GND 0m 0nH 0pF
G10   IO_L2N_AD14N_50   NC
G11   IO_L5N_HDGC_50   NC
G12   VCCO_50   POWER 50m 0.40nH 235nF
G13   IO_L8N_HDGC_50   NC
G14   IO_L9N_AD11N_50   NC
G15   IO_L9P_AD11P_50   NC
G16   IO_L11N_AD9N_50   NC
G17   VCCO_48   POWER 50m 0.40nH 235nF
G18   IO_L5P_HDGC_48   NC
G19   IO_L5N_HDGC_48   NC
G20   IO_L6P_HDGC_AD6P_47   NC
G21   IO_L5P_HDGC_AD7P_47   NC
G22   VCCO_PSIO2_502   POWER 50m 0.40nH 235nF
G23   USB0_ULPI_STP   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
G24   USB0_ULPI_TX_DATA[6]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
G25   GEM3_RGMII_RXD[3]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
G26   GND   GND 0m 0nH 0pF
G27   ref_clk2_p   NC
G28   ref_clk2_n   NC
G29   MGTAVCC_L   POWER 50m 0.40nH 235nF
G30   GND   GND 0m 0nH 0pF
G31   tx1_data_p[3]   NC
G32   tx1_data_n[3]   NC
G33   GND   GND 0m 0nH 0pF
G34   GND   GND 0m 0nH 0pF
H1   MGTHRXN2_229   NC
H2   MGTHRXP2_229   NC
H3   GND   GND 0m 0nH 0pF
H4   MGTAVTT_R   POWER 50m 0.40nH 235nF
H5   MGTHTXN1_229   NC
H6   MGTHTXP1_229   NC
H7   MGTVCCAUX_R   POWER 50m 0.40nH 235nF
H8   GND   GND 0m 0nH 0pF
H9   GND   GND 0m 0nH 0pF
H10   IO_L2P_AD14P_50   NC
H11   IO_L5P_HDGC_50   NC
H12   IO_L7N_HDGC_50   NC
H13   IO_L8P_HDGC_50   NC
H14   IO_L10N_AD10N_50   NC
H15   GND   GND 0m 0nH 0pF
H16   IO_L11P_AD9P_50   NC
H17   IO_L2N_AD14N_48   NC
H18   IO_L1P_AD15P_48   NC
H19   IO_L1N_AD15N_48   NC
H20   VCCO_47   POWER 50m 0.40nH 235nF
H21   IO_L3N_AD9N_47   NC
H22   PMU_GPO[0]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
H23   PMU_GPO[1]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
H24   GEM3_RGMII_RXD[2]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
H25   MDIO3_GEM3_MDC   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
H26   GND   GND 0m 0nH 0pF
H27   MGTAVCC_L   POWER 50m 0.40nH 235nF
H28   GND   GND 0m 0nH 0pF
H29   tx1_data_p[2]   NC
H30   tx1_data_n[2]   NC
H31   GND   GND 0m 0nH 0pF
H32   MGTAVTT_L   POWER 50m 0.40nH 235nF
H33   rx1_data_p[2]   NC
H34   rx1_data_n[2]   NC
J1   GND   GND 0m 0nH 0pF
J2   GND   GND 0m 0nH 0pF
J3   MGTHRXN1_229   NC
J4   MGTHRXP1_229   NC
J5   MGTAVTT_R   POWER 50m 0.40nH 235nF
J6   GND   GND 0m 0nH 0pF
J7   MGTREFCLK1N_228   NC
J8   MGTREFCLK1P_228   NC
J9   GND   GND 0m 0nH 0pF
J10   IO_L1N_AD15N_50   NC
J11   IO_L1P_AD15P_50   NC
J12   IO_L7P_HDGC_50   NC
J13   VCCO_50   POWER 50m 0.40nH 235nF
J14   IO_L10P_AD10P_50   NC
J15   IO_L12N_AD8N_50   NC
J16   IO_L12P_AD8P_50   NC
J17   IO_L2P_AD14P_48   NC
J18   VCCO_48   POWER 50m 0.40nH 235nF
J19   IO_L4P_AD8P_47   NC
J20   IO_L4N_AD8N_47   NC
J21   IO_L3P_AD9P_47   NC
J22   PCIE_ROOT_RESET_N   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
J23   GND   GND 0m 0nH 0pF
J24   SD1_SDIO1_DATA_OUT[6]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
J25   SD1_SDIO1_DATA_OUT[0]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
J26   GND   GND 0m 0nH 0pF
J27   MGTREFCLK1P_129   NC
J28   MGTREFCLK1N_129   NC
J29   GND   GND 0m 0nH 0pF
J30   MGTAVTT_L   POWER 50m 0.40nH 235nF
J31   tx1_data_p[1]   NC
J32   tx1_data_n[1]   NC
J33   GND   GND 0m 0nH 0pF
J34   GND   GND 0m 0nH 0pF
K1   MGTHRXN0_229   NC
K2   MGTHRXP0_229   NC
K3   MGTAVTT_R   POWER 50m 0.40nH 235nF
K4   GND   GND 0m 0nH 0pF
K5   MGTHTXN0_229   NC
K6   MGTHTXP0_229   NC
K7   GND   GND 0m 0nH 0pF
K8   MGTAVCC_R   POWER 50m 0.40nH 235nF
K9   GND   GND 0m 0nH 0pF
K10   adrv1_orx_ctrl_c   HP_LVCMOS18_S_12
K11   GND   GND 0m 0nH 0pF
K12   IO_L18N_T2U_N11_AD2N_67   NC
K13   adrv1_gpint1   HP_LVCMOS18_S_12
K14   adrv1_tx2_enable   HP_LVCMOS18_S_12
K15   adrv1_gpio_04   HP_LVCMOS18_S_12
K16   adrv1_gpio_05   HP_LVCMOS18_S_12
K17   IO_L4N_AD12N_48   NC
K18   IO_L3N_AD13N_48   NC
K19   IO_L2N_AD10N_47   NC
K20   IO_L1N_AD11N_47   NC
K21   GND   GND 0m 0nH 0pF
K22   DPAUX_DP_AUX_DATA_OE   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
K23   PMU_GPO[4]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
K24   GPIO1_GPIO1[43]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
K25   SD1_SDIO1_DATA_OUT[3]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
K26   GND   GND 0m 0nH 0pF
K27   GND   GND 0m 0nH 0pF
K28   MGTVCCAUX_L   POWER 50m 0.40nH 235nF
K29   tx1_data_p[0]   NC
K30   tx1_data_n[0]   NC
K31   MGTAVTT_L   POWER 50m 0.40nH 235nF
K32   GND   GND 0m 0nH 0pF
K33   rx1_data_p[1]   NC
K34   rx1_data_n[1]   NC
L1   GND   GND 0m 0nH 0pF
L2   GND   GND 0m 0nH 0pF
L3   MGTHRXN3_228   NC
L4   MGTHRXP3_228   NC
L5   GND   GND 0m 0nH 0pF
L6   MGTAVTT_R   POWER 50m 0.40nH 235nF
L7   MGTREFCLK0N_228   NC
L8   MGTREFCLK0P_228   NC
L9   GND   GND 0m 0nH 0pF
L10   IO_L15N_T2L_N5_AD11N_67   NC
L11   tx1_sync_n   HP_LVDS_DT_I
L12   adrv1_rx3_enable   HP_LVCMOS18_S_12
L13   adrv1_tx4_enable   HP_LVCMOS18_S_12
L14   GND   GND 0m 0nH 0pF
L15   adrv1_gpio_06   HP_LVCMOS18_S_12
L16   adrv1_gpio_07   HP_LVCMOS18_S_12
L17   IO_L4P_AD12P_48   NC
L18   IO_L3P_AD13P_48   NC
L19   IO_L2P_AD10P_47   NC
L20   IO_L1P_AD11P_47   NC
L21   DPAUX_DP_AUX_DATA_IN   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
L22   PMU_GPO[2]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
L23   GPIO1_GPIO1[38]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
L24   VCCO_PSIO1_501   POWER 50m 0.40nH 235nF
L25   SD1_SDIO1_DATA_OUT[1]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
L26   GND   GND 0m 0nH 0pF
L27   ref_clk_p   NC
L28   ref_clk_n   NC
L29   MGTAVCC_L   POWER 50m 0.40nH 235nF
L30   GND   GND 0m 0nH 0pF
L31   rx1_data_p[0]   NC
L32   rx1_data_n[0]   NC
L33   GND   GND 0m 0nH 0pF
L34   GND   GND 0m 0nH 0pF
M1   MGTHRXN2_228   NC
M2   MGTHRXP2_228   NC
M3   GND   GND 0m 0nH 0pF
M4   MGTAVTT_R   POWER 50m 0.40nH 235nF
M5   MGTHTXN3_228   NC
M6   MGTHTXP3_228   NC
M7   GND   GND 0m 0nH 0pF
M8   GND   GND 0m 0nH 0pF
M9   GND   GND 0m 0nH 0pF
M10   IO_L15P_T2L_N4_AD11P_67   NC
M11   tx1_sync_p   HP_LVDS_DT_I
M12   GND   GND 0m 0nH 0pF
M13   adrv1_gpio_03   HP_LVCMOS18_S_12
M14   adrv1_gpio_01   HP_LVCMOS18_S_12
M15   spi2_csn_adrv1   HP_LVCMOS18_S_12
M16   VCCINT   POWER 50m 0.40nH 235nF
M17   GND   GND 0m 0nH 0pF
M18   VCCINT   POWER 50m 0.40nH 235nF
M19   GND   GND 0m 0nH 0pF
M20   VCCINT   POWER 50m 0.40nH 235nF
M21   DPAUX_DP_AUX_DATA_OUT   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
M22   VCCO_PSIO1_501   POWER 50m 0.40nH 235nF
M23   SD1_SDIO1_DATA_OUT[5]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
M24   SD1_SDIO1_DATA_OUT[7]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
M25   SD1_SDIO1_DATA_OUT[2]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
M26   GND   GND 0m 0nH 0pF
M27   MGTVCCAUX_L   POWER 50m 0.40nH 235nF
M28   GND   GND 0m 0nH 0pF
M29   MGTHTXP3_128   NC
M30   MGTHTXN3_128   NC
M31   GND   GND 0m 0nH 0pF
M32   MGTAVTT_L   POWER 50m 0.40nH 235nF
M33   MGTHRXP3_128   NC
M34   MGTHRXN3_128   NC
N1   GND   GND 0m 0nH 0pF
N2   GND   GND 0m 0nH 0pF
N3   MGTHTXN2_228   NC
N4   MGTHTXP2_228   NC
N5   MGTAVTT_R   POWER 50m 0.40nH 235nF
N6   GND   GND 0m 0nH 0pF
N7   GND   GND 0m 0nH 0pF
N8   tx1_sync_1_n   HP_LVDS_DT_I
N9   tx1_sync_1_p   HP_LVDS_DT_I
N10   GND   GND 0m 0nH 0pF
N11   core_clk_n   HP_LVDS
N12   adrv1_rx4_enable   HP_LVCMOS18_S_12
N13   adrv1_orx_ctrl_b   HP_LVCMOS18_S_12
N14   VREF_67   POWER 50m 0.40nH 235nF
N15   VCCINT   POWER 50m 0.40nH 235nF
N16   GND   GND 0m 0nH 0pF
N17   VCCINT   POWER 50m 0.40nH 235nF
N18   GND   GND 0m 0nH 0pF
N19   VCCINT   POWER 50m 0.40nH 235nF
N20   GND   GND 0m 0nH 0pF
N21   DPAUX_DP_HOT_PLUG_DETECT   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
N22   PMU_GPO[5]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
N23   SD1_SDIO1_DATA_OUT[4]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
N24   SD1_SDIO1_WP   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
N25   SD1_SDIO1_CLK_OUT   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
N26   GND   GND 0m 0nH 0pF
N27   MGTREFCLK1P_128   NC
N28   MGTREFCLK1N_128   NC
N29   GND   GND 0m 0nH 0pF
N30   MGTAVTT_L   POWER 50m 0.40nH 235nF
N31   MGTHRXP2_128   NC
N32   MGTHRXN2_128   NC
N33   GND   GND 0m 0nH 0pF
N34   GND   GND 0m 0nH 0pF
P1   MGTHRXN1_228   NC
P2   MGTHRXP1_228   NC
P3   MGTAVTT_R   POWER 50m 0.40nH 235nF
P4   GND   GND 0m 0nH 0pF
P5   MGTHTXN1_228   NC
P6   MGTHTXP1_228   NC
P7   GND   GND 0m 0nH 0pF
P8   VCCO_67   POWER 50m 0.40nH 235nF
P9   IO_L14N_T2L_N3_GC_67   NC
P10   IO_L14P_T2L_N2_GC_67   NC
P11   core_clk_p   HP_LVDS
P12   adrv1_tx3_enable   HP_LVCMOS18_S_12
P13   GND   GND 0m 0nH 0pF
P14   VCCINT   POWER 50m 0.40nH 235nF
P15   GND   GND 0m 0nH 0pF
P16   VCCINT   POWER 50m 0.40nH 235nF
P17   GND   GND 0m 0nH 0pF
P18   VCCINT   POWER 50m 0.40nH 235nF
P19   GND   GND 0m 0nH 0pF
P20   VCCINT   POWER 50m 0.40nH 235nF
P21   GPIO1_GPIO1[26]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
P22   PMU_GPO[3]   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
P23   GND   GND 0m 0nH 0pF
P24   SD1_SDIO1_CD_N   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
P25   SD1_SDIO1_CMD_OUT   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
P26   GND   GND 0m 0nH 0pF
P27   GND   GND 0m 0nH 0pF
P28   MGTAVCC_L   POWER 50m 0.40nH 235nF
P29   MGTHTXP2_128   NC
P30   MGTHTXN2_128   NC
P31   MGTAVTT_L   POWER 50m 0.40nH 235nF
P32   GND   GND 0m 0nH 0pF
P33   MGTHRXP1_128   NC
P34   MGTHRXN1_128   NC
R1   GND   GND 0m 0nH 0pF
R2   GND   GND 0m 0nH 0pF
R3   MGTHTXN0_228   NC
R4   MGTHTXP0_228   NC
R5   GND   GND 0m 0nH 0pF
R6   GND   GND 0m 0nH 0pF
R7   GND   GND 0m 0nH 0pF
R8   core_clk2_n   HP_LVDS
R9   sysref_n   HP_LVDS_DT_I
R10   sysref_p   HP_LVDS_DT_I
R11   GND   GND 0m 0nH 0pF
R12   adrv1_tx1_enable   HP_LVCMOS18_S_12
R13   adrv1_orx_ctrl_d   HP_LVCMOS18_S_12
R14   GND   GND 0m 0nH 0pF
R15   VCCINT   POWER 50m 0.40nH 235nF
R16   GND   GND 0m 0nH 0pF
R17   VCCINT   POWER 50m 0.40nH 235nF
R18   GND   GND 0m 0nH 0pF
R19   VCCINT   POWER 50m 0.40nH 235nF
R20   GND   GND 0m 0nH 0pF
R21   PS_ERROR_STATUS   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
R22   PS_MODE1   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
R23   PS_MODE3   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
R24   PS_JTAG_TMS   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
R25   PS_JTAG_TCK   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
R26   GND   GND 0m 0nH 0pF
R27   MGTREFCLK0P_128   NC
R28   MGTREFCLK0N_128   NC
R29   MGTAVCC_L   POWER 50m 0.40nH 235nF
R30   GND   GND 0m 0nH 0pF
R31   MGTHTXP1_128   NC
R32   MGTHTXN1_128   NC
R33   GND   GND 0m 0nH 0pF
R34   GND   GND 0m 0nH 0pF
T1   MGTHRXN0_228   NC
T2   MGTHRXP0_228   NC
T3   GND   GND 0m 0nH 0pF
T4   GND   GND 0m 0nH 0pF
T5   GND   GND 0m 0nH 0pF
T6   IO_L10N_T1U_N7_QBC_AD4N_67   NC
T7   IO_L10P_T1U_N6_QBC_AD4P_67   NC
T8   core_clk2_p   HP_LVDS
T9   VCCO_67   POWER 50m 0.40nH 235nF
T10   adrv1_gpint2   HP_LVCMOS18_S_12
T11   IO_L6N_T0U_N11_AD6N_67   NC
T12   adrv1_reset_b   HP_LVCMOS18_S_12
T13   adrv1_gpio_02   HP_LVCMOS18_S_12
T14   VCCAUX   POWER 50m 0.40nH 235nF
T15   GND   GND 0m 0nH 0pF
T16   VCCINT   POWER 50m 0.40nH 235nF
T17   GNDADC   NC
T18   VCCADC   NC
T19   GND   GND 0m 0nH 0pF
T20   VCCINT   POWER 50m 0.40nH 235nF
T21   PS_ERROR_OUT   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
T22   PS_MODE0   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
T23   PS_MODE2   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
T24   VCCO_PSIO3_503   POWER 50m 0.40nH 235nF
T25   PS_JTAG_TDO   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
T26   GND   GND 0m 0nH 0pF
T27   GND   GND 0m 0nH 0pF
T28   GND   GND 0m 0nH 0pF
T29   MGTHTXP0_128   NC
T30   MGTHTXN0_128   NC
T31   GND   GND 0m 0nH 0pF
T32   GND   GND 0m 0nH 0pF
T33   MGTHRXP0_128   NC
T34   MGTHRXN0_128   NC
U1   GND   GND 0m 0nH 0pF
U2   GND   GND 0m 0nH 0pF
U3   GND   GND 0m 0nH 0pF
U4   IO_L18N_T2U_N11_AD2N_66   NC
U5   adrv2_tx1_enable   HP_LVCMOS18_S_12
U6   IO_L8N_T1L_N3_AD5N_67   NC
U7   VCCO_67   POWER 50m 0.40nH 235nF
U8   rx1_sync_n   HP_LVDS
U9   rx1_sync_p   HP_LVDS
U10   adrv1_test   HP_LVCMOS18_S_12
U11   IO_L6P_T0U_N10_AD6P_67   NC
U12   GND   GND 0m 0nH 0pF
U13   VCCAUX_IO   POWER 50m 0.40nH 235nF
U14   VCCAUX   POWER 50m 0.40nH 235nF
U15   VCCINT   POWER 50m 0.40nH 235nF
U16   GND   GND 0m 0nH 0pF
U17   VREFN   NC
U18   VP   NC
U19   VCCINT   POWER 50m 0.40nH 235nF
U20   GND   GND 0m 0nH 0pF
U21   PS_PROG_B   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
U22   VCCO_PSIO3_503   POWER 50m 0.40nH 235nF
U23   PS_SRST_B   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
U24   PS_REF_CLK   M3_PADH_02_S_NA_PBIDIR_18_18_NT_DR_H
U25   PS_JTAG_TDI   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
U26   GND   GND 0m 0nH 0pF
U27   USB0_MGTREFCLK2P   NC
U28   USB0_MGTREFCLK2N   NC
U29   GND   GND 0m 0nH 0pF
U30   GND   GND 0m 0nH 0pF
U31   DP0_MGTREFCLK3P   NC
U32   DP0_MGTREFCLK3N   NC
U33   GND   GND 0m 0nH 0pF
U34   GND   GND 0m 0nH 0pF
V1   adrv2_tx2_enable   HP_LVCMOS18_S_12
V2   adrv2_gpio_01   HP_LVCMOS18_S_12
V3   IO_L17N_T2U_N9_AD10N_66   NC
V4   IO_L17P_T2U_N8_AD10P_66   NC
V5   GND   GND 0m 0nH 0pF
V6   IO_L8P_T1L_N2_AD5P_67   NC
V7   rx1_os_sync_n   HP_LVDS
V8   rx1_os_sync_p   HP_LVDS
V9   adrv1_rx1_enable   HP_LVCMOS18_S_12
V10   GND   GND 0m 0nH 0pF
V11   IO_L5N_T0U_N9_AD14N_67   NC
V12   IO_L5P_T0U_N8_AD14P_67   NC
V13   VCCAUX_IO   POWER 50m 0.40nH 235nF
V14   VCCAUX_IO   POWER 50m 0.40nH 235nF
V15   GND   GND 0m 0nH 0pF
V16   VCCINT   POWER 50m 0.40nH 235nF
V17   VN   NC
V18   VREFP   NC
V19   GND   GND 0m 0nH 0pF
V20   VCCINT   POWER 50m 0.40nH 235nF
V21   PS_PADI   M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H
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[Pin Mapping] pulldown_ref pullup_ref gnd_clamp_ref power_clamp_ref ext_ref
A1   GND NC
A2   GND NC
A3   NC NC
A4   NC NC
A5   NC NC
A6   NC NC
A7   NC NC
A8   NC NC
A9   GND NC
A10   NC MGTAVCC_R
A11   GND NC
A12   NC NC
A13   NC NC
A14   GND NC
A15   NC NC
A16   NC NC
A17   NC NC
A18   NC NC
A19   GND NC
A20   NC NC
A21   NC NC
A22   NC NC
A23   NC NC
A24   GND NC
A25   NC NC
A26   NC NC
A27   NC NC
A28   GND NC
A29   NC NC
A30   NC NC
A31   NC NC
A32   NC NC
A33   GND NC
A34   GND NC
B1   NC NC
B2   NC NC
B3   NC MGTAVTT_R
B4   GND NC
B5   NC NC
B6   NC NC
B7   GND NC
B8   NC MGTAVCC_R
B9   NC NC
B10   NC NC
B11   GND NC
B12   NC NC
B13   NC NC
B14   NC NC
B15   NC NC
B16   NC NC
B17   GND NC
B18   NC NC
B19   NC NC
B20   NC NC
B21   NC NC
B22   GND NC
B23   NC NC
B24   NC NC
B25   NC NC
B26   NC NC
B27   NC NC
B28   GND NC
B29   NC NC
B30   NC NC
B31   NC MGTAVTT_L
B32   GND NC
B33   NC NC
B34   NC NC
C1   GND NC
C2   GND NC
C3   NC NC
C4   NC NC
C5   GND NC
C6   NC MGTAVCC_R
C7   NC NC
C8   NC NC
C9   GND NC
C10   GND NC
C11   GND NC
C12   NC NC
C13   NC NC
C14   NC NC
C15   GND NC
C16   NC NC
C17   NC NC
C18   NC NC
C19   NC NC
C20   GND NC
C21   NC NC
C22   NC NC
C23   NC NC
C24   NC NC
C25   GND NC
C26   NC NC
C27   NC NC
C28   GND NC
C29   NC MGTAVTT_L
C30   GND NC
C31   NC NC
C32   NC NC
C33   GND NC
C34   GND NC
D1   NC NC
D2   NC NC
D3   GND NC
D4   NC MGTAVTT_R
D5   NC NC
D6   NC NC
D7   NC MGTAVCC_R
D8   GND NC
D9   GND NC
D10   NC NC
D11   NC NC
D12   NC NC
D13   GND NC
D14   NC NC
D15   NC NC
D16   NC NC
D17   NC NC
D18   GND NC
D19   NC NC
D20   NC NC
D21   NC NC
D22   NC NC
D23   NC VCCO_PSIO2_502
D24   NC NC
D25   NC NC
D26   GND NC
D27   GND NC
D28   GND NC
D29   NC NC
D30   NC NC
D31   GND NC
D32   NC MGTAVTT_L
D33   NC NC
D34   NC NC
E1   GND NC
E2   GND NC
E3   NC NC
E4   NC NC
E5   NC MGTAVCC_R
E6   GND NC
E7   NC NC
E8   NC NC
E9   GND NC
E10   NC NC
E11   GND NC
E12   NC NC
E13   NC NC
E14   NC NC
E15   NC NC
E16   NC VCCO_49
E17   NC NC
E18   NC NC
E19   NC NC
E20   NC NC
E21   NC VCCO_47
E22   NC NC
E23   NC NC
E24   NC NC
E25   NC NC
E26   GND NC
E27   NC NC
E28   NC NC
E29   GND NC
E30   NC MGTAVTT_L
E31   NC NC
E32   NC NC
E33   GND NC
E34   GND NC
F1   NC NC
F2   NC NC
F3   NC MGTAVTT_R
F4   GND NC
F5   NC NC
F6   NC NC
F7   GND NC
F8   NC MGTVCCAUX_R
F9   GND NC
F10   NC NC
F11   NC NC
F12   NC NC
F13   NC NC
F14   NC VCCO_49
F15   NC NC
F16   NC NC
F17   NC NC
F18   NC NC
F19   GND NC
F20   NC NC
F21   NC NC
F22   NC NC
F23   NC NC
F24   NC VCCO_PSIO2_502
F25   NC NC
F26   GND NC
F27   GND NC
F28   NC MGTAVCC_L
F29   NC NC
F30   NC NC
F31   NC MGTAVTT_L
F32   GND NC
F33   NC NC
F34   NC NC
G1   GND NC
G2   GND NC
G3   NC NC
G4   NC NC
G5   GND NC
G6   NC MGTAVCC_R
G7   NC NC
G8   NC NC
G9   GND NC
G10   NC NC
G11   NC NC
G12   NC VCCO_50
G13   NC NC
G14   NC NC
G15   NC NC
G16   NC NC
G17   NC VCCO_48
G18   NC NC
G19   NC NC
G20   NC NC
G21   NC NC
G22   NC VCCO_PSIO2_502
G23   NC NC
G24   NC NC
G25   NC NC
G26   GND NC
G27   NC NC
G28   NC NC
G29   NC MGTAVCC_L
G30   GND NC
G31   NC NC
G32   NC NC
G33   GND NC
G34   GND NC
H1   NC NC
H2   NC NC
H3   GND NC
H4   NC MGTAVTT_R
H5   NC NC
H6   NC NC
H7   NC MGTVCCAUX_R
H8   GND NC
H9   GND NC
H10   NC NC
H11   NC NC
H12   NC NC
H13   NC NC
H14   NC NC
H15   GND NC
H16   NC NC
H17   NC NC
H18   NC NC
H19   NC NC
H20   NC VCCO_47
H21   NC NC
H22   NC NC
H23   NC NC
H24   NC NC
H25   NC NC
H26   GND NC
H27   NC MGTAVCC_L
H28   GND NC
H29   NC NC
H30   NC NC
H31   GND NC
H32   NC MGTAVTT_L
H33   NC NC
H34   NC NC
J1   GND NC
J2   GND NC
J3   NC NC
J4   NC NC
J5   NC MGTAVTT_R
J6   GND NC
J7   NC NC
J8   NC NC
J9   GND NC
J10   NC NC
J11   NC NC
J12   NC NC
J13   NC VCCO_50
J14   NC NC
J15   NC NC
J16   NC NC
J17   NC NC
J18   NC VCCO_48
J19   NC NC
J20   NC NC
J21   NC NC
J22   NC NC
J23   GND NC
J24   NC NC
J25   NC NC
J26   GND NC
J27   NC NC
J28   NC NC
J29   GND NC
J30   NC MGTAVTT_L
J31   NC NC
J32   NC NC
J33   GND NC
J34   GND NC
K1   NC NC
K2   NC NC
K3   NC MGTAVTT_R
K4   GND NC
K5   NC NC
K6   NC NC
K7   GND NC
K8   NC MGTAVCC_R
K9   GND NC
K10   GND VCCO_67 GND VCCO_67
K11   GND NC
K12   NC NC
K13   GND VCCO_67 GND VCCO_67
K14   GND VCCO_67 GND VCCO_67
K15   GND VCCO_67 GND VCCO_67
K16   GND VCCO_67 GND VCCO_67
K17   NC NC
K18   NC NC
K19   NC NC
K20   NC NC
K21   GND NC
K22   NC NC
K23   NC NC
K24   NC NC
K25   NC NC
K26   GND NC
K27   GND NC
K28   NC MGTVCCAUX_L
K29   NC NC
K30   NC NC
K31   NC MGTAVTT_L
K32   GND NC
K33   NC NC
K34   NC NC
L1   GND NC
L2   GND NC
L3   NC NC
L4   NC NC
L5   GND NC
L6   NC MGTAVTT_R
L7   NC NC
L8   NC NC
L9   GND NC
L10   NC NC
L11   GND VCCO_67 GND VCCO_67
L12   GND VCCO_67 GND VCCO_67
L13   GND VCCO_67 GND VCCO_67
L14   GND NC
L15   GND VCCO_67 GND VCCO_67
L16   GND VCCO_67 GND VCCO_67
L17   NC NC
L18   NC NC
L19   NC NC
L20   NC NC
L21   NC NC
L22   NC NC
L23   NC NC
L24   NC VCCO_PSIO1_501
L25   NC NC
L26   GND NC
L27   NC NC
L28   NC NC
L29   NC MGTAVCC_L
L30   GND NC
L31   NC NC
L32   NC NC
L33   GND NC
L34   GND NC
M1   NC NC
M2   NC NC
M3   GND NC
M4   NC MGTAVTT_R
M5   NC NC
M6   NC NC
M7   GND NC
M8   GND NC
M9   GND NC
M10   NC NC
M11   GND VCCO_67 GND VCCO_67
M12   GND NC
M13   GND VCCO_67 GND VCCO_67
M14   GND VCCO_67 GND VCCO_67
M15   GND VCCO_67 GND VCCO_67
M16   NC VCCINT
M17   GND NC
M18   NC VCCINT
M19   GND NC
M20   NC VCCINT
M21   NC NC
M22   NC VCCO_PSIO1_501
M23   NC NC
M24   NC NC
M25   NC NC
M26   GND NC
M27   NC MGTVCCAUX_L
M28   GND NC
M29   NC NC
M30   NC NC
M31   GND NC
M32   NC MGTAVTT_L
M33   NC NC
M34   NC NC
N1   GND NC
N2   GND NC
N3   NC NC
N4   NC NC
N5   NC MGTAVTT_R
N6   GND NC
N7   GND NC
N8   GND VCCO_67 GND VCCO_67
N9   GND VCCO_67 GND VCCO_67
N10   GND NC
N11   GND VCCO_67 GND VCCO_67
N12   GND VCCO_67 GND VCCO_67
N13   GND VCCO_67 GND VCCO_67
N14   NC VREF_67
N15   NC VCCINT
N16   GND NC
N17   NC VCCINT
N18   GND NC
N19   NC VCCINT
N20   GND NC
N21   NC NC
N22   NC NC
N23   NC NC
N24   NC NC
N25   NC NC
N26   GND NC
N27   NC NC
N28   NC NC
N29   GND NC
N30   NC MGTAVTT_L
N31   NC NC
N32   NC NC
N33   GND NC
N34   GND NC
P1   NC NC
P2   NC NC
P3   NC MGTAVTT_R
P4   GND NC
P5   NC NC
P6   NC NC
P7   GND NC
P8   NC VCCO_67
P9   NC NC
P10   NC NC
P11   GND VCCO_67 GND VCCO_67
P12   GND VCCO_67 GND VCCO_67
P13   GND NC
P14   NC VCCINT
P15   GND NC
P16   NC VCCINT
P17   GND NC
P18   NC VCCINT
P19   GND NC
P20   NC VCCINT
P21   NC NC
P22   NC NC
P23   GND NC
P24   NC NC
P25   NC NC
P26   GND NC
P27   GND NC
P28   NC MGTAVCC_L
P29   NC NC
P30   NC NC
P31   NC MGTAVTT_L
P32   GND NC
P33   NC NC
P34   NC NC
R1   GND NC
R2   GND NC
R3   NC NC
R4   NC NC
R5   GND NC
R6   GND NC
R7   GND NC
R8   GND VCCO_67 GND VCCO_67
R9   GND VCCO_67 GND VCCO_67
R10   GND VCCO_67 GND VCCO_67
R11   GND NC
R12   GND VCCO_67 GND VCCO_67
R13   GND VCCO_67 GND VCCO_67
R14   GND NC
R15   NC VCCINT
R16   GND NC
R17   NC VCCINT
R18   GND NC
R19   NC VCCINT
R20   GND NC
R21   NC NC
R22   NC NC
R23   NC NC
R24   NC NC
R25   NC NC
R26   GND NC
R27   NC NC
R28   NC NC
R29   NC MGTAVCC_L
R30   GND NC
R31   NC NC
R32   NC NC
R33   GND NC
R34   GND NC
T1   NC NC
T2   NC NC
T3   GND NC
T4   GND NC
T5   GND NC
T6   NC NC
T7   NC NC
T8   GND VCCO_67 GND VCCO_67
T9   NC VCCO_67
T10   GND VCCO_67 GND VCCO_67
T11   NC NC
T12   GND VCCO_67 GND VCCO_67
T13   GND VCCO_67 GND VCCO_67
T14   NC VCCAUX
T15   GND NC
T16   NC VCCINT
T17   NC NC
T18   NC NC
T19   GND NC
T20   NC VCCINT
T21   NC NC
T22   NC NC
T23   NC NC
T24   NC VCCO_PSIO3_503
T25   NC NC
T26   GND NC
T27   GND NC
T28   GND NC
T29   NC NC
T30   NC NC
T31   GND NC
T32   GND NC
T33   NC NC
T34   NC NC
U1   GND NC
U2   GND NC
U3   GND NC
U4   NC NC
U5   GND VCCO_66 GND VCCO_66
U6   NC NC
U7   NC VCCO_67
U8   GND VCCO_67 GND VCCO_67
U9   GND VCCO_67 GND VCCO_67
U10   GND VCCO_67 GND VCCO_67
U11   NC NC
U12   GND NC
U13   NC VCCAUX_IO
U14   NC VCCAUX
U15   NC VCCINT
U16   GND NC
U17   NC NC
U18   NC NC
U19   NC VCCINT
U20   GND NC
U21   NC NC
U22   NC VCCO_PSIO3_503
U23   NC NC
U24   NC NC
U25   NC NC
U26   GND NC
U27   NC NC
U28   NC NC
U29   GND NC
U30   GND NC
U31   NC NC
U32   NC NC
U33   GND NC
U34   GND NC
V1   GND VCCO_66 GND VCCO_66
V2   GND VCCO_66 GND VCCO_66
V3   NC NC
V4   NC NC
V5   GND NC
V6   NC NC
V7   GND VCCO_67 GND VCCO_67
V8   GND VCCO_67 GND VCCO_67
V9   GND VCCO_67 GND VCCO_67
V10   GND NC
V11   NC NC
V12   NC NC
V13   NC VCCAUX_IO
V14   NC VCCAUX_IO
V15   GND NC
V16   NC VCCINT
V17   NC NC
V18   NC NC
V19   GND NC
V20   NC VCCINT
V21   NC NC
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[Package Model]   xczu15eg_ffvb1156
[Diff Pin]   inv_pin   vdiff   tdelay_typ   tdelay_min   tdelay_max
M11   L11   100mV   0   0   0
| tx1_sync_p   HP_LVDS_DT_I_P   HP_LVDS_DT_I
N9   N8   100mV   0   0   0
| tx1_sync_1_p   HP_LVDS_DT_I_P   HP_LVDS_DT_I
P11   N11   100mV   0   0   0
| core_clk_p   HP_LVDS_P   HP_LVDS
R10   R9   100mV   0   0   0
| sysref_p   HP_LVDS_DT_I_P   HP_LVDS_DT_I
U9   U8   100mV   0   0   0
| rx1_sync_p   HP_LVDS_P   HP_LVDS
V8   V7   100mV   0   0   0
| rx1_os_sync_p   HP_LVDS_P   HP_LVDS
W5   W4   100mV   0   0   0
| tx2_sync_p   HP_LVDS_DT_I_P   HP_LVDS_DT_I
Y5   AA5   100mV   0   0   0
| tx2_sync_1_p   HP_LVDS_DT_I_P   HP_LVDS_DT_I
Y10   Y9   100mV   0   0   0
| rx2_sync_p   HP_LVDS_P   HP_LVDS
AB8   AC8   100mV   0   0   0
| rx2_os_sync_p   HP_LVDS_P   HP_LVDS
AE28   AE29   186.000mV 0ns   NA   NA
| DDR4_DQS_P5   PS_DDR4_DQS_OUT34_P  DWC_D5MQ4_34
AE32   AE33   186.000mV 0ns   NA   NA
| DDR4_DQS_P7   PS_DDR4_DQS_OUT34_P  DWC_D5MQ4_34
AH19   AJ19   186.000mV 0ns   NA   NA
| DDR4_DQS_P2   PS_DDR4_DQS_OUT34_P  DWC_D5MQ4_34
AH22   AH23   186.000mV 0ns   NA   NA
| DDR4_DQS_P3   PS_DDR4_DQS_OUT34_P  DWC_D5MQ4_34
AH28   AH29   186.000mV 0ns   NA   NA
| DDR4_DQS_P4   PS_DDR4_DQS_OUT34_P  DWC_D5MQ4_34
AJ32   AK32   186.000mV 0ns   NA   NA
| DDR4_DQS_P6   PS_DDR4_DQS_OUT34_P  DWC_D5MQ4_34
AN18   AN19   186.000mV 0ns   NA   NA
| DDR4_DQS_P0   PS_DDR4_DQS_OUT34_P  DWC_D5MQ4_34
AN21   AN22   186.000mV 0ns   NA   NA
| DDR4_DQS_P1   PS_DDR4_DQS_OUT34_P  DWC_D5MQ4_34
AN26   AN27   186.000mV 0ns   NA   NA
| DDR4_CK0   PS_DDR4_CK_OUT34_P   DWC_D5MC4_34
[Model Selector]   DWC_D5MP4_34ODT_MS
DWC_D5MP4_34   Input
DWC_D5MP4_34ODT40   Input
[Model Selector]   DWC_D5MQ4_34ODT_MS
DWC_D5MQ4_34   Input
DWC_D5MQ4_34ODT40   Input
[Define Package Model]   xczu15eg_ffvb1156
[Manufacturer]   Xilinx Inc.
[OEM]   Xilinx
[Description]   11546 ball organic flip-chip
|[Number of Sections]   1
[Number of Pins]   757
[Pin Numbers]
|[Pin Name]  Net Number   Net Name   Net's All Pins
F28   | 1   MGTAVCC_L   F28
   |G29
   |H27
   |L29
   |P28
   |R29
G6   | 2   MGTAVCC_R   G6
   |E5
   |B8
   |A10
   |C6
   |D7
   |K8
M27   | 3   MGTVCCAUX_L   M27
   |K28
F8   | 4   MGTVCCAUX_R   F8
   |H7
V28   | 5   PS_MGTRAVCC   V28
   |W30
   |Y27
   |AA29
T18   | 6   VCCADC   T18
U14   | 7   VCCAUX   U14
   |T14
U13   | 8   VCCAUX_IO   U13
   |V13
   |V14
AC14   | 9   VCCBRAM   AC14
   |Y14
   |W14
   |AB14
T20   | 10   VCCINT   T20
   |AB16
   |Y16
   |V20
   |M20
   |N19
   |M18
   |N17
   |M16
   |P20
   |P18
   |P16
   |P14
   |R19
   |R17
   |R15
   |U19
   |T16
   |U15
   |V16
   |W19
   |AA17
   |AB18
   |Y20
   |AA19
   |AB20
   |AC19
   |AC17
   |AC15
   |W15
   |AA15
   |N15
   |Y18
Y13   | 11   VCCINT_IO   Y13
   |AA13
   |AB13
   |AC13
AF14   | 12   VCCO_44   AF14
   |AJ13
E21   | 13   VCCO_47   E21
   |H20
J18   | 14   VCCO_48   J18
   |G17
E16   | 15   VCCO_49   E16
   |F14
G12   | 16   VCCO_50   G12
   |J13
AK11   | 17   VCCO_64   AK11
   |AJ8
   |AL9
AG7   | 18   VCCO_65   AG7
   |AD8
   |AF9
W8   | 19   VCCO_66   W8
   |AA9
   |Y11
T9   | 20   VCCO_67   T9
   |U7
   |P8
AJ28   | 21   VCCO_PSDDR_504   AJ28
   |AL24
   |AN25
   |AN30
   |AG27
   |AJ24
   |AL29
AE16   | 22   VCCO_PSIO0_500   AE16
   |AG17
   |AK16
L24   | 23   VCCO_PSIO1_501   L24
   |M22
D23   | 24   VCCO_PSIO2_502   D23
   |F24
   |G22
U22   | 25   VCCO_PSIO3_503   U22
   |T24
AB25   | 26   VCC_PSADC   AB25
   |AC26
AA25   | 27   VCC_PSAUX   AA25
   |Y22
   |Y23
   |AA23
AA22   | 28   VCC_PSBATT   AA22
Y25   | 29   VCC_PSDDR_PLL   Y25
   |Y24
AD26   | 30   VCC_PSINTFP   AD26
   |AD22
   |AD21
   |AD25
   |AE23
   |AC24
   |AE22
AE25   | 31   VCC_PSINTFP_DDR   AE25
   |AE24
   |AD24
AA21   | 32   VCC_PSINTLP   AA21
   |AB23
   |AB21
   |AC23
   |AC22
   |AC21
W25   | 33   VCC_PSPLL   W25
   |W24
   |W22
W17   | 34   DXN   W17
W18   | 35   DXP   W18
AP14   | 36   IO_L1N_AD11N_44   AP14
K20   | 37   IO_L1N_AD11N_47   K20
H19   | 38   IO_L1N_AD15N_48   H19
F15   | 39   IO_L1N_AD15N_49   F15
J10   | 40   IO_L1N_AD15N_50   J10
AK12   | 41   IO_L1N_T0L_N1_DBC_64   AK12
AF10   | 42   IO_L1N_T0L_N1_DBC_65   AF10
AC11   | 43   IO_L1N_T0L_N1_DBC_66   AC11
W11   | 44   IO_L1N_T0L_N1_DBC_67   W11
AN14   | 45   IO_L1P_AD11P_44   AN14
L20   | 46   IO_L1P_AD11P_47   L20
H18   | 47   IO_L1P_AD15P_48   H18
F16   | 48   IO_L1P_AD15P_49   F16
J11   | 49   IO_L1P_AD15P_50   J11
AJ12   | 50   IO_L1P_T0L_N0_DBC_64   AJ12
AE10   | 51   IO_L1P_T0L_N0_DBC_65   AE10
AC12   | 52   IO_L1P_T0L_N0_DBC_66   AC12
W12   | 53   IO_L1P_T0L_N0_DBC_67   W12
AN13   | 54   IO_L2N_AD10N_44   AN13
K19   | 55   IO_L2N_AD10N_47   K19
H17   | 56   IO_L2N_AD14N_48   H17
C16   | 57   IO_L2N_AD14N_49   C16
G10   | 58   IO_L2N_AD14N_50   G10
AM11   | 59   IO_L2N_T0L_N3_64   AM11
AH11   | 60   IO_L2N_T0L_N3_65   AH11
AB10   | 61   IO_L2N_T0L_N3_66   AB10
R13   | 62   IO_L2N_T0L_N3_67   R13
AM14   | 63   IO_L2P_AD10P_44   AM14
L19   | 64   IO_L2P_AD10P_47   L19
J17   | 65   IO_L2P_AD14P_48   J17
D16   | 66   IO_L2P_AD14P_49   D16
H10   | 67   IO_L2P_AD14P_50   H10
AL11   | 68   IO_L2P_T0L_N2_64   AL11
AH12   | 69   IO_L2P_T0L_N2_65   AH12
AB11   | 70   IO_L2P_T0L_N2_66   AB11
T13   | 71   IO_L2P_T0L_N2_67   T13
AP12   | 72   IO_L3N_AD9N_44   AP12
H21   | 73   IO_L3N_AD9N_47   H21
K18   | 74   IO_L3N_AD13N_48   K18
A16   | 75   IO_L3N_AD13N_49   A16
E10   | 76   IO_L3N_AD13N_50   E10
AM10   | 77   IO_L3N_T0L_N5_AD15N_64   AM10
AF12   | 78   IO_L3N_T0L_N5_AD15N_65   AF12
AA10   | 79   IO_L3N_T0L_N5_AD15N_66   AA10
T10   | 80   IO_L3N_T0L_N5_AD15N_67   T10
AN12   | 81   IO_L3P_AD9P_44   AN12
J21   | 82   IO_L3P_AD9P_47   J21
L18   | 83   IO_L3P_AD13P_48   L18
B16   | 84   IO_L3P_AD13P_49   B16
F10   | 85   IO_L3P_AD13P_50   F10
AL10   | 86   IO_L3P_T0L_N4_AD15P_64   AL10
AE12   | 87   IO_L3P_T0L_N4_AD15P_65   AE12
AA11   | 88   IO_L3P_T0L_N4_AD15P_66   AA11
U10   | 89   IO_L3P_T0L_N4_AD15P_67   U10
AM13   | 90   IO_L4N_AD8N_44   AM13
J20   | 91   IO_L4N_AD8N_47   J20
K17   | 92   IO_L4N_AD12N_48   K17
A15   | 93   IO_L4N_AD12N_49   A15
D10   | 94   IO_L4N_AD12N_50   D10
AP10   | 95   IO_L4N_T0U_N7_DBC_AD7N_64   AP10
AG11   | 96   IO_L4N_T0U_N7_DBC_AD7N_65   AG11
AC9   | 97   IO_L4N_T0U_N7_DBC_AD7N_66   AC9
R12   | 98   IO_L4N_T0U_N7_DBC_AD7N_67   R12
AL13   | 99   IO_L4P_AD8P_44   AL13
J19   | 100   IO_L4P_AD8P_47   J19
L17   | 101   IO_L4P_AD12P_48   L17
B15   | 102   IO_L4P_AD12P_49   B15
D11   | 103   IO_L4P_AD12P_50   D11
AP11   | 104   IO_L4P_T0U_N6_DBC_AD7P_64   AP11
AB9   | 105   IO_L4P_T0U_N6_DBC_AD7P_66   AB9
T12   | 106   IO_L4P_T0U_N6_DBC_AD7P_67   T12
AF11   | 107   IO_L4P_T0U_N6_DBC_AD7P_SMBALERT_65   AF11
G19   | 108   IO_L5N_HDGC_48   G19
D15   | 109   IO_L5N_HDGC_49   D15
G11   | 110   IO_L5N_HDGC_50   G11
AK14   | 111   IO_L5N_HDGC_AD7N_44   AK14
F21   | 112   IO_L5N_HDGC_AD7N_47   F21
AP9   | 113   IO_L5N_T0U_N9_AD14N_64   AP9
AG9   | 114   IO_L5N_T0U_N9_AD14N_65   AG9
AA12   | 115   IO_L5N_T0U_N9_AD14N_66   AA12
V11   | 116   IO_L5N_T0U_N9_AD14N_67   V11
G18   | 117   IO_L5P_HDGC_48   G18
E15   | 118   IO_L5P_HDGC_49   E15
H11   | 119   IO_L5P_HDGC_50   H11
AK15   | 120   IO_L5P_HDGC_AD7P_44   AK15
G21   | 121   IO_L5P_HDGC_AD7P_47   G21
AN9   | 122   IO_L5P_T0U_N8_AD14P_64   AN9
AG10   | 123   IO_L5P_T0U_N8_AD14P_65   AG10
Y12   | 124   IO_L5P_T0U_N8_AD14P_66   Y12
V12   | 125   IO_L5P_T0U_N8_AD14P_67   V12
F18   | 126   IO_L6N_HDGC_48   F18
D14   | 127   IO_L6N_HDGC_49   D14
F11   | 128   IO_L6N_HDGC_50   F11
AL12   | 129   IO_L6N_HDGC_AD6N_44   AL12
F20   | 130   IO_L6N_HDGC_AD6N_47   F20
AK10   | 131   IO_L6N_T0U_N11_AD6N_64   AK10
AE9   | 132   IO_L6N_T0U_N11_AD6N_65   AE9
Y9   | 133   IO_L6N_T0U_N11_AD6N_66   Y9
T11   | 134   IO_L6N_T0U_N11_AD6N_67   T11
F17   | 135   IO_L6P_HDGC_48   F17
E14   | 136   IO_L6P_HDGC_49   E14
F12   | 137   IO_L6P_HDGC_50   F12
AK13   | 138   IO_L6P_HDGC_AD6P_44   AK13
G20   | 139   IO_L6P_HDGC_AD6P_47   G20
AJ10   | 140   IO_L6P_T0U_N10_AD6P_64   AJ10
AD10   | 141   IO_L6P_T0U_N10_AD6P_65   AD10
Y10   | 142   IO_L6P_T0U_N10_AD6P_66   Y10
U11   | 143   IO_L6P_T0U_N10_AD6P_67   U11
D19   | 144   IO_L7N_HDGC_48   D19
B14   | 145   IO_L7N_HDGC_49   B14
H12   | 146   IO_L7N_HDGC_50   H12
AH13   | 147   IO_L7N_HDGC_AD5N_44   AH13
D22   | 148   IO_L7N_HDGC_AD5N_47   D22
AP8   | 149   IO_L7N_T1L_N1_QBC_AD13N_64   AP8
AH6   | 150   IO_L7N_T1L_N1_QBC_AD13N_65   AH6
AC6   | 151   IO_L7N_T1L_N1_QBC_AD13N_66   AC6
V7   | 152   IO_L7N_T1L_N1_QBC_AD13N_67   V7
E19   | 153   IO_L7P_HDGC_48   E19
C14   | 154   IO_L7P_HDGC_49   C14
J12   | 155   IO_L7P_HDGC_50   J12
AH14   | 156   IO_L7P_HDGC_AD5P_44   AH14
E22   | 157   IO_L7P_HDGC_AD5P_47   E22
AN8   | 158   IO_L7P_T1L_N0_QBC_AD13P_64   AN8
AH7   | 159   IO_L7P_T1L_N0_QBC_AD13P_65   AH7
AC7   | 160   IO_L7P_T1L_N0_QBC_AD13P_66   AC7
V8   | 161   IO_L7P_T1L_N0_QBC_AD13P_67   V8
E18   | 162   IO_L8N_HDGC_48   E18
B13   | 163   IO_L8N_HDGC_49   B13
G13   | 164   IO_L8N_HDGC_50   G13
AJ14   | 165   IO_L8N_HDGC_AD4N_44   AJ14
D20   | 166   IO_L8N_HDGC_AD4N_47   D20
AM8   | 167   IO_L8N_T1L_N3_AD5N_64   AM8
AH8   | 168   IO_L8N_T1L_N3_AD5N_65   AH8
AC8   | 169   IO_L8N_T1L_N3_AD5N_66   AC8
U6   | 170   IO_L8N_T1L_N3_AD5N_67   U6
E17   | 171   IO_L8P_HDGC_48   E17
C13   | 172   IO_L8P_HDGC_49   C13
H13   | 173   IO_L8P_HDGC_50   H13
AJ15   | 174   IO_L8P_HDGC_AD4P_44   AJ15
E20   | 175   IO_L8P_HDGC_AD4P_47   E20
AM9   | 176   IO_L8P_T1L_N2_AD5P_64   AM9
AG8   | 177   IO_L8P_T1L_N2_AD5P_65   AG8
AB8   | 178   IO_L8P_T1L_N2_AD5P_66   AB8
V6   | 179   IO_L8P_T1L_N2_AD5P_67   V6
AF13   | 180   IO_L9N_AD3N_44   AF13
C22   | 181   IO_L9N_AD3N_47   C22
C17   | 182   IO_L9N_AD11N_48   C17
A12   | 183   IO_L9N_AD11N_49   A12
G14   | 184   IO_L9N_AD11N_50   G14
AK9   | 185   IO_L9N_T1L_N5_AD12N_64   AK9
AD6   | 186   IO_L9N_T1L_N5_AD12N_65   AD6
W6   | 187   IO_L9N_T1L_N5_AD12N_66   W6
U8   | 188   IO_L9N_T1L_N5_AD12N_67   U8
AE13   | 189   IO_L9P_AD3P_44   AE13
D21   | 190   IO_L9P_AD3P_47   D21
D17   | 191   IO_L9P_AD11P_48   D17
A13   | 192   IO_L9P_AD11P_49   A13
G15   | 193   IO_L9P_AD11P_50   G15
AJ9   | 194   IO_L9P_T1L_N4_AD12P_64   AJ9
AD7   | 195   IO_L9P_T1L_N4_AD12P_65   AD7
W7   | 196   IO_L9P_T1L_N4_AD12P_66   W7
U9   | 197   IO_L9P_T1L_N4_AD12P_67   U9
AG13   | 198   IO_L10N_AD2N_44   AG13
B21   | 199   IO_L10N_AD2N_47   B21
B19   | 200   IO_L10N_AD10N_48   B19
B12   | 201   IO_L10N_AD10N_49   B12
H14   | 202   IO_L10N_AD10N_50   H14
AP7   | 203   IO_L10N_T1U_N7_QBC_AD4N_64   AP7
AF8   | 204   IO_L10N_T1U_N7_QBC_AD4N_65   AF8
AB5   | 205   IO_L10N_T1U_N7_QBC_AD4N_66   AB5
T6   | 206   IO_L10N_T1U_N7_QBC_AD4N_67   T6
AG14   | 207   IO_L10P_AD2P_44   AG14
C21   | 208   IO_L10P_AD2P_47   C21
B18   | 209   IO_L10P_AD10P_48   B18
C12   | 210   IO_L10P_AD10P_49   C12
J14   | 211   IO_L10P_AD10P_50   J14
AN7   | 212   IO_L10P_T1U_N6_QBC_AD4P_64   AN7
AE8   | 213   IO_L10P_T1U_N6_QBC_AD4P_65   AE8
AB6   | 214   IO_L10P_T1U_N6_QBC_AD4P_66   AB6
T7   | 215   IO_L10P_T1U_N6_QBC_AD4P_67   T7
AG15   | 216   IO_L11N_AD1N_44   AG15
A22   | 217   IO_L11N_AD1N_47   A22
C19   | 218   IO_L11N_AD9N_48   C19
D12   | 219   IO_L11N_AD9N_49   D12
G16   | 220   IO_L11N_AD9N_50   G16
AK7   | 221   IO_L11N_T1U_N9_GC_64   AK7
AG6   | 222   IO_L11N_T1U_N9_GC_65   AG6
Y7   | 223   IO_L11N_T1U_N9_GC_66   Y7
R9   | 224   IO_L11N_T1U_N9_GC_67   R9
AF15   | 225   IO_L11P_AD1P_44   AF15
A21   | 226   IO_L11P_AD1P_47   A21
C18   | 227   IO_L11P_AD9P_48   C18
E12   | 228   IO_L11P_AD9P_49   E12
H16   | 229   IO_L11P_AD9P_50   H16
AK8   | 230   IO_L11P_T1U_N8_GC_64   AK8
AF6   | 231   IO_L11P_T1U_N8_GC_65   AF6
Y8   | 232   IO_L11P_T1U_N8_GC_66   Y8
R10   | 233   IO_L11P_T1U_N8_GC_67   R10
AE14   | 234   IO_L12N_AD0N_44   AE14
A20   | 235   IO_L12N_AD0N_47   A20
A18   | 236   IO_L12N_AD8N_48   A18
E13   | 237   IO_L12N_AD8N_49   E13
J15   | 238   IO_L12N_AD8N_50   J15
AL7   | 239   IO_L12N_T1U_N11_GC_64   AL7
AF7   | 240   IO_L12N_T1U_N11_GC_65   AF7
AA6   | 241   IO_L12N_T1U_N11_GC_66   AA6
R8   | 242   IO_L12N_T1U_N11_GC_67   R8
AE15   | 243   IO_L12P_AD0P_44   AE15
B20   | 244   IO_L12P_AD0P_47   B20
A17   | 245   IO_L12P_AD8P_48   A17
F13   | 246   IO_L12P_AD8P_49   F13
J16   | 247   IO_L12P_AD8P_50   J16
AL8   | 248   IO_L12P_T1U_N10_GC_64   AL8
AE7   | 249   IO_L12P_T1U_N10_GC_65   AE7
AA7   | 250   IO_L12P_T1U_N10_GC_66   AA7
T8   | 251   IO_L12P_T1U_N10_GC_67   T8
AL5   | 252   IO_L13N_T2L_N1_GC_QBC_64   AL5
AF5   | 253   IO_L13N_T2L_N1_GC_QBC_65   AF5
Y3   | 254   IO_L13N_T2L_N1_GC_QBC_66   Y3
N11   | 255   IO_L13N_T2L_N1_GC_QBC_67   N11
AL6   | 256   IO_L13P_T2L_N0_GC_QBC_64   AL6
AE5   | 257   IO_L13P_T2L_N0_GC_QBC_65   AE5
Y4   | 258   IO_L13P_T2L_N0_GC_QBC_66   Y4
P11   | 259   IO_L13P_T2L_N0_GC_QBC_67   P11
AM5   | 260   IO_L14N_T2L_N3_GC_64   AM5
AG4   | 261   IO_L14N_T2L_N3_GC_65   AG4
AA5   | 262   IO_L14N_T2L_N3_GC_66   AA5
P9   | 263   IO_L14N_T2L_N3_GC_67   P9
AM6   | 264   IO_L14P_T2L_N2_GC_64   AM6
AG5   | 265   IO_L14P_T2L_N2_GC_65   AG5
Y5   | 266   IO_L14P_T2L_N2_GC_66   Y5
P10   | 267   IO_L14P_T2L_N2_GC_67   P10
AP4   | 268   IO_L15N_T2L_N5_AD11N_64   AP4
AJ4   | 269   IO_L15N_T2L_N5_AD11N_65   AJ4
W4   | 270   IO_L15N_T2L_N5_AD11N_66   W4
L10   | 271   IO_L15N_T2L_N5_AD11N_67   L10
AP5   | 272   IO_L15P_T2L_N4_AD11P_64   AP5
AH4   | 273   IO_L15P_T2L_N4_AD11P_65   AH4
W5   | 274   IO_L15P_T2L_N4_AD11P_66   W5
M10   | 275   IO_L15P_T2L_N4_AD11P_67   M10
AP6   | 276   IO_L16N_T2U_N7_QBC_AD3N_64   AP6
AJ5   | 277   IO_L16N_T2U_N7_QBC_AD3N_65   AJ5
AC4   | 278   IO_L16N_T2U_N7_QBC_AD3N_66   AC4
N8   | 279   IO_L16N_T2U_N7_QBC_AD3N_67   N8
AN6   | 280   IO_L16P_T2U_N6_QBC_AD3P_64   AN6
AJ6   | 281   IO_L16P_T2U_N6_QBC_AD3P_65   AJ6
AB4   | 282   IO_L16P_T2U_N6_QBC_AD3P_66   AB4
N9   | 283   IO_L16P_T2U_N6_QBC_AD3P_67   N9
AN4   | 284   IO_L17N_T2U_N9_AD10N_64   AN4
AF3   | 285   IO_L17N_T2U_N9_AD10N_65   AF3
V3   | 286   IO_L17N_T2U_N9_AD10N_66   V3
L11   | 287   IO_L17N_T2U_N9_AD10N_67   L11
AM4   | 288   IO_L17P_T2U_N8_AD10P_64   AM4
AE3   | 289   IO_L17P_T2U_N8_AD10P_65   AE3
V4   | 290   IO_L17P_T2U_N8_AD10P_66   V4
M11   | 291   IO_L17P_T2U_N8_AD10P_67   M11
AK4   | 292   IO_L18N_T2U_N11_AD2N_64   AK4
AE4   | 293   IO_L18N_T2U_N11_AD2N_65   AE4
U4   | 294   IO_L18N_T2U_N11_AD2N_66   U4
K12   | 295   IO_L18N_T2U_N11_AD2N_67   K12
AK5   | 296   IO_L18P_T2U_N10_AD2P_64   AK5
AD4   | 297   IO_L18P_T2U_N10_AD2P_65   AD4
U5   | 298   IO_L18P_T2U_N10_AD2P_66   U5
L12   | 299   IO_L18P_T2U_N10_AD2P_67   L12
AP2   | 300   IO_L19N_T3L_N1_DBC_AD9N_64   AP2
AJ2   | 301   IO_L19N_T3L_N1_DBC_AD9N_65   AJ2
AC1   | 302   IO_L19N_T3L_N1_DBC_AD9N_66   AC1
K16   | 303   IO_L19N_T3L_N1_DBC_AD9N_67   K16
AN2   | 304   IO_L19P_T3L_N0_DBC_AD9P_64   AN2
AH2   | 305   IO_L19P_T3L_N0_DBC_AD9P_65   AH2
AC2   | 306   IO_L19P_T3L_N0_DBC_AD9P_66   AC2
L16   | 307   IO_L19P_T3L_N0_DBC_AD9P_67   L16
AP3   | 308   IO_L20N_T3L_N3_AD1N_64   AP3
AH3   | 309   IO_L20N_T3L_N3_AD1N_65   AH3
AC3   | 310   IO_L20N_T3L_N3_AD1N_66   AC3
M14   | 311   IO_L20N_T3L_N3_AD1N_67   M14
AN3   | 312   IO_L20P_T3L_N2_AD1P_64   AN3
AG3   | 313   IO_L20P_T3L_N2_AD1P_65   AG3
AB3   | 314   IO_L20P_T3L_N2_AD1P_66   AB3
M15   | 315   IO_L20P_T3L_N2_AD1P_67   M15
AN1   | 316   IO_L21N_T3L_N5_AD8N_64   AN1
AF1   | 317   IO_L21N_T3L_N5_AD8N_65   AF1
AA1   | 318   IO_L21N_T3L_N5_AD8N_66   AA1
N12   | 319   IO_L21N_T3L_N5_AD8N_67   N12
AM1   | 320   IO_L21P_T3L_N4_AD8P_64   AM1
AF2   | 321   IO_L21P_T3L_N4_AD8P_65   AF2
AA2   | 322   IO_L21P_T3L_N4_AD8P_66   AA2
P12   | 323   IO_L21P_T3L_N4_AD8P_67   P12
AL2   | 324   IO_L22N_T3U_N7_DBC_AD0N_64   AL2
AJ1   | 325   IO_L22N_T3U_N7_DBC_AD0N_65   AJ1
Y1   | 326   IO_L22N_T3U_N7_DBC_AD0N_66   Y1
M13   | 327   IO_L22N_T3U_N7_DBC_AD0N_67   M13
AL3   | 328   IO_L22P_T3U_N6_DBC_AD0P_64   AL3
AH1   | 329   IO_L22P_T3U_N6_DBC_AD0P_65   AH1
Y2   | 330   IO_L22P_T3U_N6_DBC_AD0P_66   Y2
N13   | 331   IO_L22P_T3U_N6_DBC_AD0P_67   N13
AL1   | 332   IO_L23N_T3U_N9_64   AL1
AD1   | 333   IO_L23N_T3U_N9_65   AD1
V1   | 334   IO_L23N_T3U_N9_66   V1
K13   | 335   IO_L23N_T3U_N9_67   K13
AK1   | 336   IO_L23P_T3U_N8_64   AK1
V2   | 337   IO_L23P_T3U_N8_66   V2
L13   | 338   IO_L23P_T3U_N8_67   L13
AD2   | 339   IO_L23P_T3U_N8_I2C_SCLK_65   AD2
AK2   | 340   IO_L24N_T3U_N11_64   AK2
W1   | 341   IO_L24N_T3U_N11_66   W1
K15   | 342   IO_L24N_T3U_N11_67   K15
AE1   | 343   IO_L24N_T3U_N11_PERSTN0_65   AE1
AK3   | 344   IO_L24P_T3U_N10_64   AK3
W2   | 345   IO_L24P_T3U_N10_66   W2
L15   | 346   IO_L24P_T3U_N10_67   L15
AE2   | 347   IO_L24P_T3U_N10_PERSTN1_I2C_SDA_65   AE2
AN11   | 348   IO_T0U_N12_VRP_64   AN11
AD9   | 349   IO_T0U_N12_VRP_65   AD9
W9   | 350   IO_T0U_N12_VRP_66   W9
W10   | 351   IO_T0U_N12_VRP_67   W10
AJ7   | 352   IO_T1U_N12_64   AJ7
AH9   | 353   IO_T1U_N12_65   AH9
AA8   | 354   IO_T1U_N12_66   AA8
V9   | 355   IO_T1U_N12_67   V9
AM3   | 356   IO_T2U_N12_64   AM3
AD5   | 357   IO_T2U_N12_65   AD5
AA3   | 358   IO_T2U_N12_66   AA3
K10   | 359   IO_T2U_N12_67   K10
AP1   | 360   IO_T3U_N12_64   AP1
AG1   | 361   IO_T3U_N12_65   AG1
AB1   | 362   IO_T3U_N12_66   AB1
K14   | 363   IO_T3U_N12_67   K14
A30   | 364   MGTAVTTRCAL_L   A30
A5   | 365   MGTAVTTRCAL_R   A5
B31   | 366   MGTAVTT_L   B31
   |K31
   |P31
   |M32
   |D32
   |F31
   |H32
   |C29
   |E30
   |J30
   |N30
K3   | 367   MGTAVTT_R   K3
   |J5
   |L6
   |N5
   |P3
   |M4
   |H4
   |F3
   |D4
   |B3
T34   | 368   MGTHRXN0_128   T34
L32   | 369   MGTHRXN0_129   L32
E32   | 370   MGTHRXN0_130   E32
T1   | 371   MGTHRXN0_228   T1
K1   | 372   MGTHRXN0_229   K1
D1   | 373   MGTHRXN0_230   D1
P34   | 374   MGTHRXN1_128   P34
K34   | 375   MGTHRXN1_129   K34
D34   | 376   MGTHRXN1_130   D34
P1   | 377   MGTHRXN1_228   P1
J3   | 378   MGTHRXN1_229   J3
C3   | 379   MGTHRXN1_230   C3
N32   | 380   MGTHRXN2_128   N32
H34   | 381   MGTHRXN2_129   H34
C32   | 382   MGTHRXN2_130   C32
M1   | 383   MGTHRXN2_228   M1
H1   | 384   MGTHRXN2_229   H1
B1   | 385   MGTHRXN2_230   B1
M34   | 386   MGTHRXN3_128   M34
F34   | 387   MGTHRXN3_129   F34
B34   | 388   MGTHRXN3_130   B34
L3   | 389   MGTHRXN3_228   L3
F1   | 390   MGTHRXN3_229   F1
A3   | 391   MGTHRXN3_230   A3
T33   | 392   MGTHRXP0_128   T33
L31   | 393   MGTHRXP0_129   L31
E31   | 394   MGTHRXP0_130   E31
T2   | 395   MGTHRXP0_228   T2
K2   | 396   MGTHRXP0_229   K2
D2   | 397   MGTHRXP0_230   D2
P33   | 398   MGTHRXP1_128   P33
K33   | 399   MGTHRXP1_129   K33
D33   | 400   MGTHRXP1_130   D33
P2   | 401   MGTHRXP1_228   P2
J4   | 402   MGTHRXP1_229   J4
C4   | 403   MGTHRXP1_230   C4
N31   | 404   MGTHRXP2_128   N31
H33   | 405   MGTHRXP2_129   H33
C31   | 406   MGTHRXP2_130   C31
M2   | 407   MGTHRXP2_228   M2
H2   | 408   MGTHRXP2_229   H2
B2   | 409   MGTHRXP2_230   B2
M33   | 410   MGTHRXP3_128   M33
F33   | 411   MGTHRXP3_129   F33
B33   | 412   MGTHRXP3_130   B33
L4   | 413   MGTHRXP3_228   L4
F2   | 414   MGTHRXP3_229   F2
A4   | 415   MGTHRXP3_230   A4
T30   | 416   MGTHTXN0_128   T30
K30   | 417   MGTHTXN0_129   K30
F30   | 418   MGTHTXN0_130   F30
R3   | 419   MGTHTXN0_228   R3
K5   | 420   MGTHTXN0_229   K5
E3   | 421   MGTHTXN0_230   E3
R32   | 422   MGTHTXN1_128   R32
J32   | 423   MGTHTXN1_129   J32
D30   | 424   MGTHTXN1_130   D30
P5   | 425   MGTHTXN1_228   P5
H5   | 426   MGTHTXN1_229   H5
D5   | 427   MGTHTXN1_230   D5
P30   | 428   MGTHTXN2_128   P30
H30   | 429   MGTHTXN2_129   H30
B30   | 430   MGTHTXN2_130   B30
N3   | 431   MGTHTXN2_228   N3
G3   | 432   MGTHTXN2_229   G3
B5   | 433   MGTHTXN2_230   B5
M30   | 434   MGTHTXN3_128   M30
G32   | 435   MGTHTXN3_129   G32
A32   | 436   MGTHTXN3_130   A32
M5   | 437   MGTHTXN3_228   M5
F5   | 438   MGTHTXN3_229   F5
A7   | 439   MGTHTXN3_230   A7
T29   | 440   MGTHTXP0_128   T29
K29   | 441   MGTHTXP0_129   K29
F29   | 442   MGTHTXP0_130   F29
R4   | 443   MGTHTXP0_228   R4
K6   | 444   MGTHTXP0_229   K6
E4   | 445   MGTHTXP0_230   E4
R31   | 446   MGTHTXP1_128   R31
J31   | 447   MGTHTXP1_129   J31
D29   | 448   MGTHTXP1_130   D29
P6   | 449   MGTHTXP1_228   P6
H6   | 450   MGTHTXP1_229   H6
D6   | 451   MGTHTXP1_230   D6
P29   | 452   MGTHTXP2_128   P29
H29   | 453   MGTHTXP2_129   H29
B29   | 454   MGTHTXP2_130   B29
N4   | 455   MGTHTXP2_228   N4
G4   | 456   MGTHTXP2_229   G4
B6   | 457   MGTHTXP2_230   B6
M29   | 458   MGTHTXP3_128   M29
G31   | 459   MGTHTXP3_129   G31
A31   | 460   MGTHTXP3_130   A31
M6   | 461   MGTHTXP3_228   M6
F6   | 462   MGTHTXP3_229   F6
A8   | 463   MGTHTXP3_230   A8
R28   | 464   MGTREFCLK0N_128   R28
L28   | 465   MGTREFCLK0N_129   L28
G28   | 466   MGTREFCLK0N_130   G28
L7   | 467   MGTREFCLK0N_228   L7
G7   | 468   MGTREFCLK0N_229   G7
C7   | 469   MGTREFCLK0N_230   C7
R27   | 470   MGTREFCLK0P_128   R27
L27   | 471   MGTREFCLK0P_129   L27
G27   | 472   MGTREFCLK0P_130   G27
L8   | 473   MGTREFCLK0P_228   L8
G8   | 474   MGTREFCLK0P_229   G8
C8   | 475   MGTREFCLK0P_230   C8
N28   | 476   MGTREFCLK1N_128   N28
J28   | 477   MGTREFCLK1N_129   J28
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[Model Data]
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[End Model Data]
[End Package Model]
| Models and submodels in the file (13): DWC_D5MC4_34 (I/O), DWC_D5MP4_34 (I/O), DWC_D5MP4_34ODT40 (Input), DWC_D5MQ4_34 (I/O), DWC_D5MQ4_34ODT40 (Input), HP_LVCMOS18_F_12 (I/O), HP_LVCMOS18_F_8 (I/O), HP_LVCMOS18_S_12 (I/O), HP_LVCMOS18_S_8 (I/O), HP_LVDS (I/O), HP_LVDS_DT_I (Input), M18_PADH_12_F_NA_PBIDIR_18_18_NT_DR_H (I/O), M3_PADH_02_S_NA_PBIDIR_18_18_NT_DR_H (I/O)
